# Keil uVision project keil.uvprojx, settings and files
target Server (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: server +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: KEIL
  c include: src/headers/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Server Sources
    ./src/: main.c
    ./src/server/: binaryUtils.c server.c mempool.c
    ./src/server/protocol/: arp.c ip.c icmp.c
  group Files
    ./tmp/keil_c51/: files.g1.c
